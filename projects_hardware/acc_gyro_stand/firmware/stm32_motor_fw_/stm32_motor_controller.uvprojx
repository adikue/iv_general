# Keil uVision project stm32_motor_controller.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_motor_controller
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: .\sources;.\sources\config;.\sources\HAL;.\sources\fatfs;.\sources\fatfs\fatfs;.\sources\fatfs\fatfs\drivers;.\sources\fatfs\fatfs\option;.\RTE;.\RTE\Device\STM32F405RG;.\sources\motor
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HAL
    ./sources/HAL/: hal.c timer.c usart.c
  group motor
    ./sources/motor/: moto_ctrl.c
  group main
    ./sources/: main.c
  group fatfs
    ./sources/fatfs/: tm_stm32f4_delay.c tm_stm32f4_fatfs.c main_config_processor.c sd_processing.c
    ./sources/fatfs/fatfs/: ff.c diskio.c
    ./sources/fatfs/fatfs/drivers/: fatfs_sd_sdio.c
    ./sources/fatfs/fatfs/option/: unicode.c
  group wifi
    ./sources/HAL/: wifi.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_gpio.c
    RTE/Device/STM32F405RG/: RTE_Device.h startup_stm32f40_41xxx.s stm32f4xx_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
