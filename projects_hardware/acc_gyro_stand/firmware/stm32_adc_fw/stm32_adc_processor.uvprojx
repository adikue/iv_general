# Keil uVision project stm32_adc_processor.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_adc_processor +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: .\sources;.\sources\config;.\sources\HAL;.\sources\SPL;.\sources\fatfs;.\sources\fatfs\fatfs;.\sources\fatfs\fatfs\drivers;.\sources\sd_processing
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./sources/: main.c
  group HAL
    ./sources/HAL/: hal.c spi.c adc.c sd.c
  group sd_fat
    ./sources/fatfs/: tm_stm32f4_delay.c tm_stm32f4_fatfs.c
    ./sources/fatfs/fatfs/: diskio.c ff.c
    ./sources/fatfs/fatfs/option/: unicode.c
    ./sources/fatfs/fatfs/drivers/: fatfs_sd_sdio.c
  group sd_processor
    ./sources/sd_processing/: sd_processing.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS/Lib/ARM/: arm_cortexM4l_math.lib
  group ::Device
    RTE/Device/STM32F405RG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_exti.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0
